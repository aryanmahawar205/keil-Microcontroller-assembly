# Keil uVision project 8051 Data Transfers (Experiment 1).uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51ED2 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) XRAM (0-0x6FF) CLOCK(33000000) MODP2
  output: 8051 Data Transfers (Experiment 1)
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: task_1.a51
